# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: main.c
  group LCD1602
    ./: lcd1602.h lcd1602.c
  group DS18B20
    ./: ds18b20.h ds18b20.c
  group Delay
    ./: delay.h delay.c
